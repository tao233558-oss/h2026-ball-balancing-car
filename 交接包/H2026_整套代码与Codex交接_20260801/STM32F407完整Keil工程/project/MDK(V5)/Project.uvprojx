# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_HAL_DRIVER,USE_USB_FS,STM32_HAL_NO_LEGACY,STM32F40_41xxx,STM32F407xx,
  c misc: --split_sections
  c include: ..\..\app;..\..\board;..\..\bsp;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\module;..\..\bsp\uart;..\..\bsp\OLED;..\..\bsp\keys;..\..\bsp\motor;..\..\bsp\encoder;..\..\bsp\ir_array;..\..\bsp\stepper;..\..\bsp\vision_uart;..\..\bsp\timebase;..\..\bsp\jy61p_uart;..\..\bsp\usb_cdc;..\..\protocol\vision_ascii;..\..\control;..\..\libraries\STM32F4xx_HAL_Driver_USB\Inc;..\..\libraries\STM32_USB_Device_Library\Core\Inc;..\..\libraries\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../app/: main.c
    ../../module/: stm32f4xx_it.c
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group BSP
    ../../bsp/uart/: bsp_uart.c
    ../../bsp/: bsp_IRtracking.c
    ../../bsp/OLED/: oled.c
    ../../bsp/keys/: bsp_keys.c
    ../../bsp/motor/: bsp_motor.c
    ../../bsp/encoder/: bsp_encoder.c
    ../../bsp/ir_array/: bsp_ir_array.c
    ../../control/: speed_pi.c ball_balance.c ball_beam_controller.c
    ../../bsp/stepper/: bsp_stepper.c
    ../../bsp/vision_uart/: bsp_vision_uart.c
    ../../bsp/timebase/: bsp_timebase.c
    ../../bsp/jy61p_uart/: bsp_jy61p_uart.c
    ../../protocol/vision_ascii/: vision_ascii_parser.c
  group USB CDC
    ../../bsp/usb_cdc/: bsp_usb_cdc.c usbd_conf.c usbd_desc.c
    ../../libraries/STM32F4xx_HAL_Driver_USB/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
    ../../libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Board
    ../../board/: board.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../../: README.md
